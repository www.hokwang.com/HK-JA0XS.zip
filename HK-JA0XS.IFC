Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: HK-JA04S、HK-JA05S.IFC
Time: 2022-01-04T05:41:07
Written by: SwIFC
Made in: SolidWorks 2021

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0 m

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0 m

# IfcBuildingElementProxy: NJA上蓋SA01
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: NJA下蓋SA01
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: NJA外殼SA01
In: Default Storey
PredefinedType: ELEMENT; Material: Steel

# IfcBuildingElementProxy: NJA外殼固定片SA01
In: Default Storey
PredefinedType: ELEMENT; Material: Steel
